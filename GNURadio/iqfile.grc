options:
  parameters:
    author: lilacsat
    generate_options: qt_gui
    id: iqfile
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[+0.707+0.707j, -0.707+0.707j, +0.707-0.707j, -0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: qpsk_180
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, +0.707-0.707j, -0.707+0.707j, +0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: qpsk_270
  id: variable_constellation_rect
  parameters:
    const_points: '[+0.707-0.707j, +0.707+0.707j, -0.707-0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: qpsk_90
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707+0.707j, -0.707-0.707j, +0.707+0.707j, +0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/lilacsat/b_data
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lilacsat/b_data_1
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lilacsat/b_data_2
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lilacsat/b_data_3
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lilacsat/b
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/lilacsat/cos_out.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_1_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_1_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_90
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_180
  states: {}
- name: digital_constellation_decoder_cb_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_270
  states: {}
- name: lilacsat_sync_det_b_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '255'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '255'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '255'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '255'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_file_source_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [blocks_file_source_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [blocks_file_source_0, '0', digital_constellation_decoder_cb_0_0_0_0, '0']
- [blocks_file_source_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', lilacsat_sync_det_b_0, '0']
- [blocks_unpack_k_bits_bb_1_0, '0', lilacsat_sync_det_b_0_0, '0']
- [blocks_unpack_k_bits_bb_1_0_0, '0', lilacsat_sync_det_b_0_0_0, '0']
- [blocks_unpack_k_bits_bb_1_0_0_0, '0', lilacsat_sync_det_b_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_unpack_k_bits_bb_1_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', blocks_unpack_k_bits_bb_1_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0_0, '0', blocks_unpack_k_bits_bb_1_0_0_0, '0']
- [lilacsat_sync_det_b_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [lilacsat_sync_det_b_0_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [lilacsat_sync_det_b_0_0_0, out, blocks_pdu_to_tagged_stream_0_0_0, pdus]
- [lilacsat_sync_det_b_0_0_0_0, out, blocks_pdu_to_tagged_stream_0_0_0_0, pdus]

metadata:
  file_format: 1
